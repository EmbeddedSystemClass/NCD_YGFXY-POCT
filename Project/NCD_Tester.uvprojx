# Keil uVision project NCD_Tester.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NCD_Tester +hex
  AfterMake: D:\Program Files\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\AppLunch;..\COM;..\Datas;..\Function;..\HardwareDriver;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Task;..\ThirdParty\Fatfs\src;..\ThirdParty\lwip-1.4.1\src\include;..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\ThirdParty\lwip-1.4.1\src\include\netif;..\ThirdParty\lwip-1.4.1\src\include\lwip;..\ThirdParty\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\ThirdParty\lwip-1.4.1\port\STM32F4x7;..\ThirdParty\lwip-1.4.1\User;..\ThirdParty\cJSON-master;..\UI;..\ThirdParty\FreeRTOS\inc;..\Daos;..\Entity;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../AppLunch/: main.c SystemInit.c stm32f4xx_it.c
  group Drivers
    ../HardwareDriver/: Led_Driver.c SPI1_Driver.c SPI2_Driver.c Usart1_Driver.c Usart2_Driver.c Usart3_Driver.c Usart4_Driver.c Usart6_Driver.c TLV5617_Driver.c DRV8825_Driver.c ADS8325_Driver.c CodeScanner_Driver.c MLX90614_Driver.c RTC_Driver.c LCD_Driver.c Iwdg_Driver.c CardLimit_Driver.c Wifi_Driver.c PT8211_Driver.c TM1623_Driver.c MAX4051_Driver.c Timer3_Driver.c SD_SPI_Driver.c Timer4_Driver.c LEDCheck_Driver.c DS18b20_Driver.c
  group Functions
    ../Function/: CodeScanFunction.c GetLCDInputFun.c SelfTest_Fun.c WifiFunction.c OutModel_Fun.c SDFunction.c PlaySong_Function.c Universal_Fun.c Test_Fun.c Motor_Fun.c LabServer_Fun.c ReadBarCode_Fun.c Printf_Fun.c Paidui_Fun.c SystemResetFun.c IAP_Fun.c HttpClient_Fun.c
  group Tasks
    ../Task/: LwipCom_Task.c LwipDHCP_Task.c CodeScan_Task.c SystemUI_Task.c Iwdg_Task.c Universal_Task.c PlaySong_Task.c Test_Task.c LwipServerForLab_Task.c SystemStart_Task.c Paidui_Task.c LcdInput_Task.c HttpClient_Task.c
  group UI
    ../UI/: WelcomePage.c LunchPage.c SleepPage.c SelectUserPage.c SampleIDPage.c WaittingCardPage.c PreReadCardPage.c TimeDownNorPage.c TestPage.c PaiDuiPage.c SystemSetPage.c ShowDeviceInfoPage.c SetDeviceIDPage.c SetDeviceInfoPage.c UserMPage.c NetPreSetPage.c NetSetPage.c WifiSetPage.c NetInfoPage.c RecordPage.c ShowResultPage.c AdjustPage.c ReTestPage.c OtherSetPage.c AdjustLedPage.c CheckQRPage.c AboutUsPage.c ServerSetPage.c ErrorRecordPage.c AdjustRecordPage.c MaintenancePage.c MaintenanceRecordPage.c QualityPage.c QualityRecordPage.c QualityDetailPage.c
  group Entity
    ../Entity/: Operator.h Device.h TestData.h QRCode.h ItemConstData.h DateTime.h AdjustData.h Temperature.h PaiduiUnitData.h ReTestData.h Define.h MotorData.h NetWork.h DeviceAdjust.h DeviceError.h DeviceMaintenance.h DeviceQuality.h RemoteSoftInfo.h
  group DataS
    ../Datas/: Timer_Data.c MyTest_Data.c UI_Data.c System_Data.c SystemSet_Data.c RemoteSoft_Data.c ItemConst_Data.c Maintenance_Data.c Quality_Data.c
  group Daos
    ../Daos/: TestDataDao.c SystemSet_Dao.c AppFileDao.c WifiDao.c RemoteSoftDao.c DeviceDao.c DeviceAdjustDao.c DeviceErrorDao.c DeviceMaintenanceDao.c DeviceQualityDao.c RecordDataDao.c
  group LwipUser
    ../ThirdParty/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
    ../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
    ../ThirdParty/lwip-1.4.1/User/: netconf.c stm32f4x7_eth_bsp.c
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group COM
    ../COM/: Delay.c QueueUnits.c CRC16.c MyEncryptTool.c CRC_CCITT.c MyTools.c MyQueue.c MyMem.c MyStack.c MyLink.c Intent.c Md5.c HttpPostTool.c JsonToObject.c Utf8ToGBK.c HttpDownSoft.c MyLock.c
  group FreertOS
    ../ThirdParty/FreeRTOS/src/: heap_4.c list.c port.c queue.c tasks.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Fatfs
    ../ThirdParty/Fatfs/src/: diskio.c ff.c user_fatfs.c
    ../ThirdParty/Fatfs/src/option/: syscall.c
  group Lwip_1.4.1
    ../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Doc
    ../DOC/: README.txt
  group CJson
    ../ThirdParty/cJSON-master/: cJSON.c
